# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ATSAMD21G18A Atmel
  pack: Keil.SAMD21_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: F_CPU = 48000000, __SAMD21J18A__
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: debug.c gpio.c main.c udc.c usb.c usb_descriptors.c startup_samd21.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.1
